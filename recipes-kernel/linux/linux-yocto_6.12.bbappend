require linux-yocto-ti-am335x.inc

KBRANCH:ti-am335x  = "v6.12/standard/ti-soc"

